# Keil uVision project demo.uvprojx, settings and files
target stm32f1xx_app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app_demo +hex
  AfterMake: fromelf.exe --bin -o f103_app/app_demo.bin f103_app/app_demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\common;..\..\hardware\board\stm32f1xx\startup;..\..\hardware\board\stm32f1xx\STM32F10x_StdPeriph_Driver\inc;..\..\hardware\board\stm32f1xx;..\..\hardware\hal;..\..\thirdparty\FreeRTOS\Source\include;..\..\thirdparty\FreeRTOS\Source\portable\stm32f1xx;..\..\middleware
  memory RVCT4: ROM 0x8004000 size 0x2a000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../../modules/application/: app_main.c
  group hal
    ../../hardware/hal/: hal_board.c hal_gpio.c hal_usart.c
  group middleware
    ../../middleware/: os_datastruct.c os_middleware.c os_trace_log.c
  group freertos
    ../../thirdparty/FreeRTOS/Source/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_protable_stm32f1xx
    ../../thirdparty/FreeRTOS/Source/portable/stm32f1xx/: port.c
  group stm32f1xx_std_drv_lib
    ../../hardware/board/stm32f1xx/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group stm32f1xx_startup
    ../../hardware/board/stm32f1xx/startup/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.1.1
